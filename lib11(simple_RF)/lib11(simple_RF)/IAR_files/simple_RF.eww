<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>D:\OURS_CC2530LIB\lib10(HumiTempLight)\IAR_files\HumiTempLight.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simple_RF.ewp</path>
  </project>
  <batchBuild/>
</workspace>


